# Keil uVision project 项目.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 项目
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB
  c include: ..\user;..\Libraries\Inc;..\Libraries\Include;..\APP;..\module;..\Core\Include;..\Libraries\Device\ST\STM32F1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../Libraries/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../: startup_stm32f103xb.s
  group USER
    ../user/: main.c gpio.c spi.c usart.c dma.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group APP
    ../APP/: OTA.c
  group module
    ../module/: led.c flash.c
  group HAL
    ../Libraries/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_pwr.c
